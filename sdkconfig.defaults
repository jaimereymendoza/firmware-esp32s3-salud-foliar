## sdkconfig.defaults
```kconfig
CONFIG_LOG_DEFAULT_LEVEL_ERROR=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=12288
CONFIG_ESP_TASK_WDT_INIT=n
```
